# Keil uVision project Main_project.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Main_project +hex
  AfterMake: fromelf --bin --output .\TIK_PION.bin .\Main_project.axf
  c flags: Optim=1 wLevel=1
  c define: ARM_MATH_CM3
  c include: .\CMSIS;.\DRIVER\inc;.\DRIVER\src;.\USB;.\FAT;.\OLED;.\MENU;..\new_loader;.\fatfs;..\Bootloader
  asm include: .\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./: main.c stm32f10x_it.c wav.c IIR.c ADC.c Flash.c FM25V10.c EXT_ADC.c Keyboard.c Params.c Reg.c RealTime.c FLASH_AT45DB.c Road.c fft_calc.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group DRIVER
    ./DRIVER/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_crc.c stm32f10x_flash.c
  group Startup
    ./CMSIS/: startup_stm32f10x_md.s
  group USB
    ./USB/: DiskImg.c usbuser.c mscuser.c usbcore.c usbdesc.c usbhw.c
  group FAT
    ./FAT/: Retarget.c _fs_ffind.c _fs_fclose.c _fs_fcreate.c _fs_fdelete.c _fs_FlashIO.c _fs_flushbuf.c _fs_fopen.c _fs_frename.c _fs_getfsize.c _fs_read.c _fs_setfpos.c _fs_write.c File_Config.c fs_fanalyse.c fs_fcheck.c fs_fdefrag.c fs_fdelete.c fs_ffree.c SPI_STM32F103.c fs_fat.c fs_time.c fs_lib.c fs_finit.c fs_FlashPrg.c
  group OLED
    ./OLED/: ssd1303.c vga_lib.c font_6x8.c font_7x10_thin.c font_7x10_bold.c font_12x16.c font_4x7.c
    ./: logos.c
  group MENU
    ./MENU/: Types.c Items.c Menu.c
  group DSP_LIB
    ./CMSIS/: arm_cortexM3l_math.lib
  group fatfs
    ./fatfs/: ff.c mmc_32f1.c
    ./fatfs/option/: ccsbcs.c
